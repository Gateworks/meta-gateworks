# Append path for gateworks ventana layer to include our defconfig
FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"
