SRCREV = "c2f11d2a4b7e94a956985c50e0f2cd85bbb98fc3"

SRC_URI = "git://github.com/Gateworks/imx-kobs.git;protocol=https"
