include compat-wireless.inc

SRC_URI[md5sum] = "1400098dd8d9c65ee2e28b1f56a60469"
SRC_URI[sha256sum] = "fc16f3accd56de8616c68707c623268ff80f52c1017bddb94800cafb990545bb"

